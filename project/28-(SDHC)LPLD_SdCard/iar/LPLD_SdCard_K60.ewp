# IAR project LPLD_SdCard_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DX256xxx10 Freescale MK60DX256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: LPLD_K60
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class; ..\..\..\lib\Me; ..\app; ..\app; ..\..\..\lib; ..\..\..\lib\common; ..\..\..\lib\CPU; ..\..\..\lib\Jay
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPLD_SdCard_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class; ..\..\..\lib\Jay
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: LPLD_SdCard_K60.hex
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: LPLD_SdCard_K60.bin
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_BOOT_K60DN512.icf
  group app
    ../app/: k60_card.h LPLD_SdCard.c
  group car
    $EW_DIR$/信标/xiugai/lib/common/: Car_control.c Car_Control.h encoder.c encoder.h hongwai.c hongwai.h McNamm_wheel_control.c McNamm_wheel_control.h Motor.c Motor.h Picture_deal.c Picture_deal.h pid.c pid.h Variable.c Variable.h
  group lib/common
    $EW_DIR$/信标/xiugai/lib/common/: alloc.c assert.c assert.h common.h findtrack.c findtrack.h include.h io.c io.h menu.c menu.h pit.c pit.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    $EW_DIR$/信标/xiugai/lib/CPU/: MK60DZ10.h startup_K60.s system_MK60DZ10.c system_MK60DZ10.h
  group lib/LPLD
    $EW_DIR$/信标/xiugai/lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/DEV
    $EW_DIR$/信标/xiugai/lib/LPLD/DEV/: DEV_LCD.c DEV_LCD.h
  group lib/LPLD/HW
    $EW_DIR$/信标/xiugai/lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_CAN.c HW_CAN.h HW_DAC.c HW_DAC.h HW_DMA.c HW_DMA.h HW_ENET.c HW_ENET.h HW_FLASH.c HW_FLASH.h HW_FLEXBUS.c HW_FLEXBUS.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_I2C.c HW_I2C.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_NVIC.c HW_NVIC.h HW_PDB.c HW_PDB.h HW_PIT.c HW_PIT.h HW_RTC.c HW_RTC.h HW_SDHC.c HW_SDHC.h HW_SPI.c HW_SPI.h HW_TSI.c HW_TSI.h HW_UART.c HW_UART.h HW_USB.c HW_USB.h HW_WDOG.c HW_WDOG.h
  group xy
    $EW_DIR$/信标/xiugai/lib/Jay/: adc.c adc.h Bluetooth.c Bluetooth.h DEV_SCCB.c DEV_SCCB.h flash.c flash.h function.c function.h global.c global.h Img.c Img.h key.c key.h OLED.c OLED.h OV7725.c OV7725.h OV7725_REG.h
    $EW_DIR$/信标/xiugai/lib/common/: imagehandle.c imagehandle.h
