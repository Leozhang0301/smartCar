<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LPLD_SdCard_K60.ewp</path>
    </project>
    <batchBuild />
</workspace>
